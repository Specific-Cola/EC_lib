# Keil uVision project Template.uvprojx, settings and files
target Template (6180000::V6.18::ARMCLANG)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx,ARM_MATH_CM4,ARM_MATH_ROUNDING,ARM_MATH_MATRIX_CHECK,__TARGET_FPU_VFP,__FPU_PRESENT
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/DSP/Include;../Drivers/CMSIS/Include;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../application;../application/songs;../EC_lib/config;../EC_lib/bsp/bsp_timer;../EC_lib/bsp/bsp_dwt;../EC_lib/bsp/bsp_can;../EC_lib/bsp/bsp_uart;../EC_lib/bsp/bsp_spi;../EC_lib/bsp/bsp_pwm;../EC_lib/bsp/bsp_delay;../EC_lib/bsp/bsp_exti;../EC_lib/bsp/bsp_gpio;../EC_lib/algorithm;../EC_lib/algorithm/PID;../EC_lib/algorithm/crc;../EC_lib/algorithm/LQR;../EC_lib/algorithm/KalmanFilter;../EC_lib/algorithm/Mahony;../EC_lib/device/BMI088;../EC_lib/device/RM_remote;../EC_lib/device/Buzzer;../EC_lib/device/referee;../EC_lib/device/Motor;../EC_lib/device/Motor/djiMotor;../EC_lib/device/Motor/DMMotor
  asm include: ..\Core\Inc;../Core/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c can.c dma.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group application
    ../application/: CalculateThread.c AttitudeThread.c
  group EC_lib/bsp
    ../EC_lib/bsp/bsp_can/: bsp_can.c
    ../EC_lib/bsp/bsp_delay/: bsp_delay.c
    ../EC_lib/bsp/bsp_spi/: bsp_spi.c
    ../EC_lib/bsp/bsp_uart/: bsp_usart.c
    ../EC_lib/bsp/bsp_pwm/: bsp_pwm.c
    ../EC_lib/bsp/bsp_dwt/: bsp_dwt.c
    ../EC_lib/bsp/bsp_timer/: bsp_timer.c
    ../EC_lib/bsp/bsp_gpio/: bsp_gpio.c
  group EC_lib/device
    ../EC_lib/device/RM_remote/: RM_remote.c
    ../EC_lib/device/Buzzer/: Buzzer.c
    ../EC_lib/device/referee/: referee_sender.c
    ../EC_lib/device/RGBled/: RGBled.c
  group EC_lib/device/BMI088
    ../EC_lib/device/BMI088/: BMI088driver.c BMI088reg.h
  group EC_lib/device/motor
    ../EC_lib/device/Motor/: Motor.c
    ../EC_lib/device/Motor/djiMotor/: djiMotor.c
    ../EC_lib/device/Motor/DMMotor/: DMMotor.c
  group EC_lib/algorithm
    ../EC_lib/algorithm/: user_lib.c
    ../EC_lib/algorithm/PID/: controller.c
    ../EC_lib/algorithm/KalmamFilter/: kalman_filter.c QuaternionEKF.c
    ../EC_lib/algorithm/crc/: crc8.c crc16.c
    ../EC_lib/algorithm/Mahony/: MahonyAHRS.c
  group EC_lib/config
    ../EC_lib/Config/: CanPacket.h Setting.h struct_typedef.h
    ../EC_lib/config/: KeyMap.h Parameter.h
    ../EC_lib/device/referee/: referee_info.h
  group Drivers/CMSIS/DSP
    ../Drivers/CMSIS/DSP/Source/MatrixFunctions/: arm_mat_add_f32.c arm_mat_mult_f32.c arm_mat_inverse_f32.c arm_mat_trans_f32.c arm_mat_sub_f32.c arm_mat_init_f32.c
software components: CMSIS:CORE 5.4.0
